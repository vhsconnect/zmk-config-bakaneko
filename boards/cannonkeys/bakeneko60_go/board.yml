## boards/cannonkeys/bakeneko60_go/board.yml
```yaml
board:
  name: bakeneko60_go
  vendor: cannonkeys
  socs:
    - name: nrf52840
      variants:
        - name: zmk
```
